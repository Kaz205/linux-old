## drivers/ddcci/ddcci-backlight/Kconfig
```kconfig
config DDCCI_BACKLIGHT
	tristate "DDCCI backlight Driver"
	help
	  DDCCI Driver for monitors.
```
